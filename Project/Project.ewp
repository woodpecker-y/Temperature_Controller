# IAR project Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152R8 STM8L152R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: HAVE_ADC_BSP1; HAVE_RTC_EXT; HAVE_18b20; STM8L15X_HD; HAVE_COM_BSP; HAVE_EXTI; HAVE_RF_BSP; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LCD; HAVE_DBG; HAVE_BEEP; HAVE_KEY; HAVE_FLASH_EXT; HAVE_SHT2x
  ICCSTM8.CCIncludePath2: ..\User\inc; ..\Board\; ..\Lib\include\bsp\; ..\Lib\include\hal\; ..\Lib\include\Libraries\; ..\Lib\include\; ..\Lib\include\Module\; ..\Lib\include\Utili\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: FY-2200_Soft_V60 (4)(下载的ID网络号必须在4###)-2019.08.19.hex
  ILINK.IlinkOutputFile: TempCollector.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\Lib\ADF.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C6 STM8L151C6
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; USE_FULL_ASSERT; HAVE_COM; HAVE_EXTI; HAVE_RF; HAVE_ADC; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LCD; HAVE_DBG; HAVE_BEEP; HAVE_RFID; HAVE_KEY
  OBJCOPY.OOCOutputFile: LockingValve-1.1.0.160630.hex
  ILINK.IlinkOutputFile: Project.out
  group Board
    ../Board/: board.c board.h pin.h
  group Docs
    ../Docs/: readme.txt
  group Lib
    ../Lib/: ADF.a
    ../Lib/include/BSP/: bsp.h
    ../User/inc/: cj188.h disp.h error.h menu.h modbus.h protocol.h sysparams.h task_adc.h task_config.h task_disp.h task_key.h task_list.h task_main.h task_report.h task_rf.h
    ../Lib/include/HAL/: utili.h
  group User
    ../User/src/: adc_bsp.c apply_rf.c bsp_adc_bsp.c bsp_com_bsp.c bsp_rtc_ext.c bsp_si4432.c cj188.c com_bsp.c disp.c ds18b20.c error.c LCD_Driver.c main.c menu.c modbus.c protocol.c rtc_ext.c RTC_inter.c stm8l15x_it.c sysparams.c task_adc.c task_config.c task_disp.c task_ds18b20.c task_key.c task_main.c task_report.c task_rf.c verify.c
    ../User/inc/: adc_bsp.h apply_rf.h
